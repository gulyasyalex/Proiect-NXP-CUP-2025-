# Repository gulyasyalex/Proiect-NXP-CUP-2025-

File README.md:

# Debix Smart RC Car — NXP Cup 2025
(For more Information visit Docs folder)
This project runs the **image processing** and **control logic** for the smart RC car using a **Debix Model B** with an **NXP i.MX 8M Plus** processor.  
It handles:
- Camera capture & processing (**OpenCV**)
- Pure Pursuit steering calculation
- TCP & Serial communication to the Teensy
- Optional TCP client to connect to your website for data/debug

---

## Project Structure

```
Proiect-NXP-CUP-2025-/
├── build/                # Build output for Debix C++ app
├── include/              # C++ header files and modules
├── src/                  # C++ source files
├── out/                  # (Optional) Generated output/logs
├── test/                 # Test code
├── Teensy-Code/          # Teensy firmware(separate build using Platformio)
├── VisionDebixTCP/       # Python TCP client
│   ├── TCPclient.py
├── .venv/                # Python virtual environment for TCP client
├── CMakeLists.txt        # C++ build configuration
├── debix-systemd-setup.txt # Systemd service setup instructions
└── README.md
```

---

## Requirements

**Debix Model B** running Linux  
**CMake** >= 3.15  
**g++** or Clang  
**OpenCV** installed  
**Python 3** (for TCP client)  
Teensy must be flashed separately with Platformio

---

## Build Instructions — C++ Debix App in command line

1. From the project root:
   cmake -S . -B build

2. Build the project:
   cmake --build build

3. The executable will be in `build/`:
   ./build/DEBIX

---

## Run Instructions

### ✅ Run C++ Debix App

1. Make sure:
   - USB camera is connected
   - Teensy is connected
   - ENABLE_TCP_SITE_DEBUG is 1 if you want web access / 0 if in race mode

2. Run your app:
   ./build/DEBIX

### ✅ Run Python TCP Client

1. Activate your Python virtual environment:
   source .venv/bin/activate

2. Go to your TCP client folder:
   cd VisionDebixTCP
   python TCPclient.py

---

## ⚡ Teensy Firmware

The `Teensy-Code/` folder holds your Teensy microcontroller code.  
Flash it separately using **PlatformIO**.

---

## ✅ Tips

- Use `config.h` for all kind of config settings.
- Check camera details with `v4l2-ctl --list-devices`.

## KiCad design Teensy-Code/PCB-Kicad/Modul_Main_Board/Modul_Main_Board.kicad_pcb

Parts:
C1, C2: CP_Radial_D10.0mm_P5.00mm
D1: LED; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IC1: TEENSY_4.0; TEENSY40_1; Manufacturer_Part_Number TEENSY 4.0
J1: Pixy Cam1; IDC-Header_2x04_P2.54mm_Vertical
J2: Pixy Cam2; IDC-Header_2x04_P2.54mm_Vertical
J4, J5, J6: HC-SR04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J7: Servo; PinHeader_1x03_P2.54mm_Vertical
J8: ESC; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J9: ESP8266; PinSocket_1x04_P2.54mm_Vertical
J10: LcdModule; IDC-Header_2x04_P2.54mm_Vertical
J12: Screw Conn1; KF3012P; Manufacturer_Part_Number KF301-2P
J13: On/Off Switch; PinHeader_1x03_P2.54mm_Vertical
J14: XT60-M; AMASS_XT60-M; PARTREV V1.2
J15, J16: Exposed Pins; PinHeader_1x14_P2.54mm_Vertical
R1, R2, R3, R4, R5, R7, R8, R9: 2k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R6: 2K; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R10: 220; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
U1: XL6009

Connections:
+5V: C2.1, IC1.33 (VIN_(3.6_TO_5.5_VOLTS)), J1.2, J2.2, J4.1, J5.1, J6.1, J7.2, J8.2, J9.2, J10.7, J16.14, U1.3 (OUT+)
+BAT: C1.1, J12.1, J13.1, J13.3, J14.P (POS), U1.1 (IN+)
-BAT: C1.2, J12.2, J14.N (NEG), U1.2 (IN-)
DECREMENT: IC1.23 (16), J10.4, J16.4
ECHO1: IC1.4 (2), J4.3, J15.4, R2.1, R3.1, R3.2
ECHO2: IC1.6 (4), J5.3, J15.6, R5.1, R6.1, R6.2
ECHO3: IC1.8 (6), J6.3, J15.8, R8.1, R9.1, R9.2
GND: C2.2, D1.1 (K), IC1.1 (GND_1), IC1.32 (GND_3), J1.6, J2.6, J4.4, J5.4, J6.4, J7.1, J8.1, J9.1, J10.8, J15.1, J16.13, R1.2, R4.2, R7.2, U1.4 (OUT-)
INCREMENT: IC1.24 (17), J10.3, J16.5
LED: IC1.28 (21), J16.9, R10.1
LEFT: IC1.22 (15), J10.1, J16.3
unnamed: D1.2 (A), R10.2
unnamed: IC1.31 (3.3V(250_MA_MAX)), J16.12
unnamed: IC1.12 (10), J15.12
unnamed: IC1.27 (20), J16.8
unnamed: R1.1, R2.2
unnamed: R4.1, R5.2
unnamed: R7.1, R8.2
RIGHT: IC1.21 (14), J10.2, J16.2
RX: IC1.2 (0), J9.3, J15.2
SCL: IC1.26 (19), J10.5, J16.7
SDA: IC1.25 (18), J10.6, J16.6
SIG_ESC: IC1.30 (23), J8.3, J16.11
SIG_SERVO: IC1.29 (22), J7.3, J16.10
SPI_MISO: IC1.14 (12), J1.1, J2.1, J15.14
SPI_MOSI: IC1.13 (11), J1.4, J2.4, J15.13
SPI_SCK: IC1.20 (13), J1.3, J2.3, J16.1
SPI_SS1: IC1.10 (8), J1.7, J15.10
SPI_SS2: IC1.11 (9), J2.7, J15.11
TRIG1: IC1.5 (3), J4.2, J15.5
TRIG2: IC1.7 (5), J5.2, J15.7
TRIG3: IC1.9 (7), J6.2, J15.9
TX: IC1.3 (1), J9.4, J15.3

Notes on the sheet:
+5V
GND
Voltage Conversion
Voltage Dividers +5V -> +3.3V
GND
+5V
Motors
Distance Sensors
Displayed Information
Cameras

Board: 2 copper layers, 80.0 x 100.0 mm, 33 parts (0 on the bottom side), 33 nets.

## KiCad design Teensy-Code/PCB-Kicad/Modul_Lcd_Butoane/Modul_Lcd_Butoane.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6, H11, H12, H13, H14, H15, H16: MountingHole; MountingHole_3.2mm_M3
IC1, IC11: AMS1117 +3.3v; SOT229P700X180-4N; Manufacturer_Part_Number ams1117-3.3v
J1, J11: LcdModule; IDC-Header_2x04_P2.54mm_Vertical
J2, J12: LCD_I2C; PinSocket_1x04_P2.54mm_Horizontal
R1, R2, R3, R4, R11, R12, R13, R14: 1k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
SW1, SW11: SW_Left; SW_PUSH-12mm
SW2, SW12: SW_Right; SW_PUSH-12mm
SW3, SW13: SW_Increment; SW_PUSH-12mm
SW4, SW14: SW_Decrement; SW_PUSH-12mm

Connections:
+3.3Vout: IC1.2 (VOUT_1), IC11.2 (VOUT_1), SW1.1, SW2.1, SW3.1, SW4.1, SW11.1, SW12.1, SW13.1, SW14.1
+5V: IC1.3 (VIN), IC11.3 (VIN), J1.7, J2.3, J11.7, J12.3
DECREMENT: J1.4, J11.4, R4.1, R14.1, SW4.2, SW14.2
GND: IC1.1 (GROUND/ADJUST), IC11.1 (GROUND/ADJUST), J1.8, J2.4, J11.8, J12.4, R1.1, R2.1, R3.2, R4.2, R11.1, R12.1, R13.2, R14.2
INCREMENT: J1.3, J11.3, R3.1, R13.1, SW3.2, SW13.2
LEFT: J1.1, J11.1, R1.2, R11.2, SW1.2, SW11.2
RIGHT: J1.2, J11.2, R2.2, R12.2, SW2.2, SW12.2
SCL: J1.5, J2.1, J11.5, J12.1
SDA: J1.6, J2.2, J11.6, J12.2

Board: 2 copper layers, 150.0 x 144.0 mm, 34 parts (0 on the bottom side), 9 nets.

## Commit log

2024-11-12 Vision code that runs with ELP usb camera
2024-11-27 Deleted unnecessary features
2024-12-05 updated line recognition, extended lines, middle lines
2024-12-05 Working perspective change
2024-12-06 Added 2 line 1 line functionality
2024-12-09 working with frame overlay
2024-12-09 added test cases
2024-12-10 fixed some intersection bug and added pure pursuit circle radius with small issues persisting around intersected points detection
2024-12-11 working pure pursuit radius and direction point
2024-12-12 (working)previous solution had problems with push
2024-12-12 update circleRadius to lookAheadDistance
2024-12-12 added Steering angle in degrees
2024-12-18 added C++ classes and mapped Servo angle
2024-12-26 slow but working servo
2025-01-17 first working test
2025-01-22 added CurvatureRadius(test needed)
2025-02-02 (feat) added functional pure pursuit
    - handled speed adjustment
    - added serial
    - added display with rotary
2025-02-08 (fix) Reorganized config file structure
2025-03-14 menu + finish_line
2025-03-16 (feat + fix) intersection - fixed one line mirroring with mirroring function - added new speed formula - added state machine
2025-03-28 (fix) fixed k min k max
    - Flashed BlHeliS
    - Added Status LED
    - Time on track 9.4s with lookahead 50cm/50cm
2025-03-31 Recovered clean project after Git object corruption
2025-03-31 9.3s RUN
2025-04-05 9.5s new config
2025-04-05 under 9s setup
2025-04-07 (feat) 8,795s clean run
    - Fixed intersection bugs
    - Can go more laps repeatedly without miss
    - Added boot up start
2025-04-10 issues..
2025-04-11 Bucharest first test day commit
2025-04-12 (feat)Speed Fix and Initial line Jiggle
2025-04-15 1st Place Run Bucharest(Jiggle alot and no Honor lap)
2025-04-17 (fix) Organized files
2025-04-29 (feat) finish line working - need to fix 350 edf after finish
2025-05-02 (fix) last working update with edf fix and good speed
2025-05-03 (feat) 8.77s
2025-05-04 9.7s official run with box stop ( still check blue led)
2025-05-06 (feat) Added Ramer-Douglas-Pecker(under 9s setup)
2025-05-07 (feat) 8.4s run
2025-05-07 (check) tried longestline in FOLLOWING_LINE
2025-05-08 FEAT(removed APPROACHING mode) amazing Results, competition setup
2025-05-08 Competition Setup 08/05/2025
2025-05-09 commit with errors
2025-05-10 (GoodCompetitionSetup) 8.7s run with finishLine
2025-05-12 better cornering but still 9s?
2025-05-13 EindHovenSetup
2025-05-14 not good finish Line detection
2025-06-09 after Eindhoven(6th place setup)
2025-06-09 changed skeleton to OPENCV version
2025-06-19 Update config.h undefinedPoint
2025-06-28 added teensy code
2025-06-28 TcpClient.py update
2025-06-28 structure update
2025-08-25 add MIT license
2025-08-25 Added Docs
2025-08-25 Docs revision
2025-08-25 Added Algorithm in docs
2026-04-23 2026_code_Revisit_1
2026-04-23 2026_code_Revisit2
2026-04-23 init
2026-04-23 Apply debix-stable clean files over main
2026-04-28 updated segmentEdges!
